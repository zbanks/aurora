# IAR project Project.ewp, settings and files
configuration STM32F051 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.PreInclude: C:\Users\Eric\Desktop\mystuff\documents\code\IAR\Bit Bang Digital LED Strip\inc\bespeckle.h
  ICCARM.CCIncludePath2: ..\..\Bit Bang Digital LED Strip\inc; ..; ..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F0XX_MD.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F031 (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: STM32F0XX_LD.hex
configuration STM32F072 (ARM, debug)
  as the first configuration, except:
configuration STM32F030 (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: STM32F0XX_LD.hex
configuration STM32F042 (ARM, debug)
  as the first configuration, except:
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s startup_stm32f031.s startup_stm32f042.s startup_stm32f051.s startup_stm32f072.s
    ../: system_stm32f0xx.c
  group StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../../Bit Bang Digital LED Strip/src/: bespeckle.c
    ../: hal.c main.c stm32f0xx_it.c
